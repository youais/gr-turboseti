options:
  parameters:
    author: ychai
    generate_options: qt_gui
    id: ts_usrpsource_ideal
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: buffer_60s
  id: variable
  parameters:
    value: samp_rate * 60
  states: {}
- name: n_coarse_chan
  id: variable
  parameters:
    value: '4'
  states: {}
- name: n_fine_chans
  id: variable
  parameters:
    value: int(samp_rate/n_coarse_chan)
  states: {}
- name: variable_low_pass_filter_taps_0
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: n_fine_chans/2
    gain: '1.0'
    samp_rate: samp_rate
    width: 200e3
    win: firdes.WIN_BLACKMAN
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 5e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: ant_list
  id: parameter
  parameters:
    comment: |-
      can acquire data via USRP:
      1a, 1c, 1f, 2a, 2b, 2h, 3c, 1k, 4g, 5c

      all ant:
      1a, 1b, 1c, 1d, 1e, 1f, 1g, 1h, 1j, 1k
      2a, 2b, 2c, 2d, 2e, 2f, 2g, 2h, 2j, 2k, 2l, 2m
      3c, 3d, 3e, 3f, 3g, 3h, 3j, 3l
      4e, 4f, 4g, 4h, 4j, 4k, 4l
      5b, 5c, 5e, 5g, 5h
    label: antennae list
    type: str
    value: 1a, 1c, 1f, 2a, 2b, 2h, 3c, 1k, 4g, 5c
  states: {state: disabled}
- name: ata_fft_block_0
  id: ata_fft_block
  parameters:
    fft_size: n_fine_chans
  states: {state: disabled}
- name: az
  id: parameter
  parameters:
    comment: dec deg
    label: az
    type: eng_float
    value: '0'
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0_0_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: n_fine_chans
  states: {}
- name: blocks_complex_to_mag_squared_0_0_1
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: n_fine_chans
  states: {}
- name: blocks_complex_to_mag_squared_0_1_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: n_fine_chans
  states: {}
- name: blocks_complex_to_mag_squared_0_2
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: n_fine_chans
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: int(n_fine_chans)
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: int(n_fine_chans)
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: int(n_fine_chans)
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: int(n_fine_chans)
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: int(n_fine_chans)
    type: complex
  states: {state: disabled}
- name: dec
  id: parameter
  parameters:
    comment: dec deg
    label: dec
    type: eng_float
    value: '5.225785'
  states: {}
- name: drift_rate_resolution
  id: parameter
  parameters:
    type: eng_float
    value: '0'
  states: {state: disabled}
- name: el
  id: parameter
  parameters:
    comment: dec deg
    label: el
    type: eng_float
    value: '0'
  states: {state: disabled}
- name: f_start
  id: parameter
  parameters:
    label: start freq
    type: eng_float
    value: 540e6
  states: {}
- name: f_stop
  id: parameter
  parameters:
    label: stop freq
    type: eng_float
    value: 550e6
  states: {}
- name: fcntr
  id: parameter
  parameters:
    label: centre frequency
    type: eng_float
    value: 545e6
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: n_fine_chans
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(n_fine_chans)
  states: {}
- name: fft_vxx_1_0
  id: fft_vxx
  parameters:
    fft_size: n_fine_chans
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(n_fine_chans)
  states: {}
- name: fft_vxx_1_0_0
  id: fft_vxx
  parameters:
    fft_size: n_fine_chans
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(n_fine_chans)
  states: {}
- name: fft_vxx_1_0_0_0
  id: fft_vxx
  parameters:
    fft_size: n_fine_chans
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(n_fine_chans)
  states: {}
- name: n_ints_in_file
  id: parameter
  parameters:
    label: '# integrations'
    type: intx
    value: '64'
  states: {}
- name: pfb_channelizer_ccf_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '72'
    bus_conns: '[[0,],]'
    ch_map: '[]'
    nchans: n_coarse_chan
    osr: '1.0'
    taps: variable_low_pass_filter_taps_0
  states: {state: disabled}
- name: ra
  id: parameter
  parameters:
    comment: dec hrs
    label: RA
    type: eng_float
    value: '7.456805'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: sample rate
    type: eng_float
    value: 4e6
  states: {}
- name: src_id
  id: parameter
  parameters:
    label: source name
    type: str
    value: '"luyten"'
  states: {}
- name: tsamp
  id: parameter
  parameters:
    label: time step in secs
    type: eng_float
    value: '1'
  states: {}
- name: tstart
  id: parameter
  parameters:
    label: obs start time
    type: eng_float
    value: '0'
  states: {}
- name: turboseti_find_et_sync_0
  id: turboseti_find_et_sync
  parameters:
    append_output: 'False'
    blank_dc: 'True'
    coarse_chan: '0'
    f_start: f_start
    f_stop: f_stop
    filename: test0_1
    flagging: 'False'
    gpu_backend: 'False'
    gpu_id: '0'
    kernels: 'False'
    log_level_int: '1'
    max_drift: '4.0'
    min_drift: '0.00001'
    n_coarse_chan: '1'
    n_fine_chans: n_fine_chans
    n_ints_in_file: n_ints_in_file
    obs_info: 'False'
    out_dir: ./
    precision: '1'
    snr: '25.0'
    source_name: src_id
    src_dej: dec
    src_raj: ra
    tsamp: tsamp
    tstart: tstart
  states: {}
- name: turboseti_find_et_sync_0_0
  id: turboseti_find_et_sync
  parameters:
    append_output: 'False'
    blank_dc: 'True'
    coarse_chan: '0'
    f_start: f_start
    f_stop: f_stop
    filename: test0_2
    flagging: 'False'
    gpu_backend: 'False'
    gpu_id: '0'
    kernels: 'False'
    log_level_int: '1'
    max_drift: '4.0'
    min_drift: '0.00001'
    n_coarse_chan: '1'
    n_fine_chans: n_fine_chans
    n_ints_in_file: n_ints_in_file
    obs_info: 'False'
    out_dir: ./
    precision: '1'
    snr: '25.0'
    source_name: src_id
    src_dej: dec
    src_raj: ra
    tsamp: tsamp
    tstart: tstart
  states: {}
- name: turboseti_find_et_sync_0_0_0
  id: turboseti_find_et_sync
  parameters:
    append_output: 'False'
    blank_dc: 'True'
    coarse_chan: '0'
    f_start: f_start
    f_stop: f_stop
    filename: test0_3
    flagging: 'False'
    gpu_backend: 'False'
    gpu_id: '0'
    kernels: 'False'
    log_level_int: '1'
    max_drift: '4.0'
    min_drift: '0.00001'
    n_coarse_chan: '1'
    n_fine_chans: n_fine_chans
    n_ints_in_file: n_ints_in_file
    obs_info: 'False'
    out_dir: ./
    precision: '1'
    snr: '25.0'
    source_name: src_id
    src_dej: dec
    src_raj: ra
    tsamp: tsamp
    tstart: tstart
  states: {}
- name: turboseti_find_et_sync_0_0_0_0
  id: turboseti_find_et_sync
  parameters:
    append_output: 'False'
    blank_dc: 'True'
    coarse_chan: '0'
    f_start: f_start
    f_stop: f_stop
    filename: test0_4
    flagging: 'False'
    gpu_backend: 'False'
    gpu_id: '0'
    kernels: 'False'
    log_level_int: '1'
    max_drift: '4.0'
    min_drift: '0.00001'
    n_coarse_chan: '1'
    n_fine_chans: n_fine_chans
    n_ints_in_file: n_ints_in_file
    obs_info: 'False'
    out_dir: ./
    precision: '1'
    snr: '25.0'
    source_name: src_id
    src_dej: dec
    src_raj: ra
    tsamp: tsamp
    tstart: tstart
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: fcntr
    dc_offs_enb0: '""'
    dev_addr: '"mgmt_addr=10.11.1.20"'
    dev_args: '""'
    gain0: '0'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: '1'
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: '2'
  states: {}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: '3'
  states: {}
- name: virtual_sink_1_0_0_0
  id: virtual_sink
  parameters:
    stream_id: '4'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: '1'
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: '2'
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: '4'
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: '3'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_stream_to_vector_0, '0']
- [analog_sig_source_x_0, '0', blocks_stream_to_vector_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_stream_to_vector_0_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_stream_to_vector_0_0_0_0, '0']
- [analog_sig_source_x_0, '0', pfb_channelizer_ccf_0, '0']
- [ata_fft_block_0, '0', turboseti_find_et_sync_0, '0']
- [blocks_complex_to_mag_squared_0_0_0_0, '0', virtual_sink_1_0_0_0, '0']
- [blocks_complex_to_mag_squared_0_0_1, '0', virtual_sink_1_0, '0']
- [blocks_complex_to_mag_squared_0_1_0, '0', virtual_sink_1_0_0, '0']
- [blocks_complex_to_mag_squared_0_2, '0', virtual_sink_1, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_1, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_1_0, '0']
- [blocks_stream_to_vector_0_0_0, '0', fft_vxx_1_0_0, '0']
- [blocks_stream_to_vector_0_0_0_0, '0', fft_vxx_1_0_0_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_complex_to_mag_0, '0']
- [fft_vxx_1, '0', blocks_complex_to_mag_squared_0_2, '0']
- [fft_vxx_1_0, '0', blocks_complex_to_mag_squared_0_0_1, '0']
- [fft_vxx_1_0_0, '0', blocks_complex_to_mag_squared_0_0_0_0, '0']
- [fft_vxx_1_0_0_0, '0', blocks_complex_to_mag_squared_0_1_0, '0']
- [pfb_channelizer_ccf_0, '0', ata_fft_block_0, '0']
- [pfb_channelizer_ccf_0, '0', blocks_stream_to_vector_0, '0']
- [pfb_channelizer_ccf_0, '1', blocks_stream_to_vector_0_0, '0']
- [pfb_channelizer_ccf_0, '2', blocks_stream_to_vector_0_0_0_0, '0']
- [pfb_channelizer_ccf_0, '3', blocks_stream_to_vector_0_0_0, '0']
- [uhd_usrp_source_0, '0', pfb_channelizer_ccf_0, '0']
- [virtual_source_0, '0', blocks_vector_to_stream_0, '0']
- [virtual_source_0, '0', turboseti_find_et_sync_0, '0']
- [virtual_source_0_0, '0', turboseti_find_et_sync_0_0, '0']
- [virtual_source_0_0_0, '0', turboseti_find_et_sync_0_0_0_0, '0']
- [virtual_source_0_1, '0', turboseti_find_et_sync_0_0_0, '0']

metadata:
  file_format: 1
